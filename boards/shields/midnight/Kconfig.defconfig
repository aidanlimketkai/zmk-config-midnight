## boards/shields/midnight/Kconfig.defconfig
```kconfig
if SHIELD_MIDNIGHT

config ZMK_KEYBOARD_NAME
    default "midnight"

endif # SHIELD_MIDNIGHT
```
